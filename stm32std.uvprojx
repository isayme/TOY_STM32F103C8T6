# Keil uVision project stm32std.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32std +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\STM32F10x_StdPeriph\Driver\inc;.\STM32F10x_StdPeriph\CMSIS;.\UserCommon\inc;.\Hardware\inc;.\FreeRTOS\Source\include;.\FreeRTOS\Source\portable\RVDS\ARM_CM3;.\uGUI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StdPeriph_Startup
    ./STM32F10x_StdPeriph/CMSIS/startup/arm/: startup_stm32f10x_md.s
  group StdPeriph_CMSIS
    ./STM32F10x_StdPeriph/CMSIS/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
  group StdPeriph_Libraries
    ./STM32F10x_StdPeriph/Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS_CORE
    ./FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ./FreeRTOS/Source/portable/MemMang/: heap_4.c
    ./FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group uGUI
    ./uGUI/: ugui.c
  group User
    ./User/: main.c
  group UserCommon
    ./UserCommon/src/: delay.c
  group Hardware
    ./Hardware/src/: iic.c oled_ssd1315.c pwm.c uart.c spi.c led.c lcd_st7789v2.c
  group Doc
    ./Doc/: README.txt
